Commit message: Add files via upload

File: src/alfr3/urdf/alfr3.urdf (robot description, URDF)
Before this commit: robot alfr3, 6 links, 5 joints
Joints:
- joint base_fixed_joint: origin xyz=0 0 0 rpy=0 0 0 -> (none)
- joint castor_wheel_joint: type continuous -> fixed
